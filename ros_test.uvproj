# Keil uVision project ros_test.uvproj, settings and files
target ros_test (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: geometry +hex
  c flags: Optim=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --cpp
  c include: .\App;.\Bsp;.\CMSIS;.\CMSIS\include;.\Math;.\ros_lib;.\STM32F4xx_StdPeriph_Driver\inc;.\User;.\FWLIB\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group start
    ./CMSIS/: startup_stm32f10x_md.s
  group user
    ./User/: includes.h main.c ros.h Stm32Hardware.h system.c system.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group bsp
    ./Bsp/: usart3.c usart3.h
  group lib
    ./FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group cmsis
    ./CMSIS/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group roslib
    ./ros_lib/: duration.cpp time.cpp
  group math
    ./Math/: fast_math.c fast_math.h mv_math.c mv_math.h
